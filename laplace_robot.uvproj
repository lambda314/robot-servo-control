# Keil uVision project laplace_robot.uvproj, settings and files
target robot (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: laplace_robot +hex
  c flags: Optimize=8 SizeSpeed=1
  group robot.c
    ./: timer.c uart.c ps2.c lvd.c eeprom.c delay.c ir.c pcatimer.c laplace_robot.c
  group robot.h
    ./: delay.h ps2.h lvd.h timer.h uart.h stc12c5a60s2.h eeprom.h datatype.h ir.h pcatimer.h
